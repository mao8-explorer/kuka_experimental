Commit message: urrdf-ee_pose整理

File: kuka_kr210_r2700/urdf/kuka_kr210_r2700.urdf (robot description, URDF)
Before this commit: robot kuka_kr210_r2700, 9 links, 8 joints
Joints:
- joint joint_a6: origin xyz=0 0 0.169867899999995 rpy=0 0 0 -> xyz=0 0 0.221867899999995 rpy=0 0 0
